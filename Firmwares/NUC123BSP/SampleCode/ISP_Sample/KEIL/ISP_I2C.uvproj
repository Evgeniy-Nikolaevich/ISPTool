# Keil uVision project ISP_I2C.uvproj, settings and files
target ISP_I2C (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC123_ISP_I2C0_PF2_PF3_CTL_PB14
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC123\Include;..\..\..\Library\StdDriver\inc;..\ISP_UART;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../../../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../: targetdev.c fmc_user.c isp_user.c
    ../ISP_I2C/: i2c_transfer.c main.c

# Keil uVision project ISP_HID.uvproj, settings and files
target ISP_HID (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC120VE3DN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC100_ISP_HID_PB15
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\;..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group User
    ../: fmc_user.c isp_user.c targetdev.c
    ../ISP_HID/: descriptors.c hid_transfer.c main.c
  group Library
    ../../../Library/StdDriver/src/: usbd.c

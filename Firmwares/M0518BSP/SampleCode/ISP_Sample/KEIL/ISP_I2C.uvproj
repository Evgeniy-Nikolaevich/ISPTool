# Keil uVision project ISP_I2C.uvproj, settings and files
target ISP_I2C (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M0518SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: M0518_ISP_I2C0_PA8_PA9_CTL_PA10
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M0518\Include;..\..\..\Library\StdDriver\inc;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M0518.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../Library/Device/Nuvoton/M0518/Source/: system_M0518.c
    ../../../Library/Device/Nuvoton/M0518/Source/ARM/: startup_M0518.s
  group Source files
    ../: fmc_user.c isp_user.c targetdev.c
    ../ISP_I2C/: i2c_transfer.c main.c
